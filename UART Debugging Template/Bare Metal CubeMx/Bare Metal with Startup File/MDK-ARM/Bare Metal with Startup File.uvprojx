# Keil uVision project Bare Metal with Startup File.uvprojx, settings and files
target Bare Metal with Startup File (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Bare Metal with Startup File +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C031xx
  c include: ../Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include;..\MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application/MDK-ARM
    ./: startup_stm32c031xx.s
  group Application/User
    ../Src/: main.c
    ./: main_with_HAL_Header_code.txt main.h config.c config.h USART.c USART.h LED.c LED.h
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal_cortex.c stm32c0xx_hal.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32c0xx.c
software components: CMSIS:CORE 5.6.0
